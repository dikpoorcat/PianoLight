# Keil uVision project 钢琴灯光项目.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WS2812驱动 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\HARDWARE\WS2812;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\WDG;..\WS2812驱动_F103;..\WS2812驱动_F103_V1.0;..\USER;..\HARDWARE\ADC;..\HARDWARE\LT_Protocol
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group New Group
    ./: main.c global.h
    ../HARDWARE/WS2812/: WS2812.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LT_Protocol/: LT_Protocol.c
